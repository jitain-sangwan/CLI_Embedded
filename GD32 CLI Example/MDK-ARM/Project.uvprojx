# Keil uVision project Project.uvprojx, settings and files
target GD32E230G_START (6190000::V6.19::ARMCLANG)
  device: GD32E230G8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\..\..\..\GD32E23x_Firmware_Library\GD32E23x_standard_peripheral\Include;..\..\..\..\GD32E23x_Firmware_Library\CMSIS;..\..\..\..\GD32E23x_Firmware_Library\CMSIS\GD\GD32E23x\Include;..\..\..\Utilities;..\..\01_GPIO_Running_LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../: main.c systick.c gd32e23x_it.c cli.c cli_cmd.c console.c fifo.c uart_driver.c cli.h console.h fifo.h uart_driver.h relay.h relay.c variables.h
  group CMSIS
    ../../../../GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group GD32E23x_Peripherals
    ../../../../GD32E23x_Firmware_Library/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group GD32E230_START
    ../../../Utilities/: gd32e230g_start.c
  group Startup
    ../../../../GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.1.1
